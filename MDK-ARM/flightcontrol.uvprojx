# Keil uVision project flightcontrol.uvprojx, settings and files
target flightcontrol (6160000::V6.16::ARMCLANG)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flightcontrol +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\FreeRTOS\Source\include;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\Core\Filght\l2c;..\Core\Filght\log;..\Core\Filght\mpu6050;..\Core\Filght\serial;..\Core\Filght\freertos;..\Core\Filght\pwm;..\Core\Filght\hmc5883l;..\Core\Filght\filgh_math;..\Core\Filght\mahony;..\Core\test\vofa;..\Core\BasicDataStructure;..\Core\Filght\motor;..\Core\Filght\bmp;..\Core\Filght\pid;..\Core\Filght\filght_init;..\Core\Filght\filght_mode;..\Core\Filght\bus;..\Core\Filght\gps;..\Core\Filght\qmc5883
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c gpio.c stm32f3xx_hal_timebase_tim.c system.c
  group Application/User/Core/Flight
    ../Core/Filght/l2c/: hal_i2c.c
    ../Core/Filght/log/: log.c
    ../Core/Filght/mpu6050/: mpu6050.c
    ../Core/Filght/serial/: usb.c usb_mode.c
    ../Core/Filght/freertos/: freertos_task.c freertos_mes_queue.c
    ../Core/Filght/pwm/: pwm.c tim_it.c
    ../Core/Filght/filgh_math/: flight_math.c
    ../Core/Filght/mahony/: mahony.c
    ../Core/Filght/motor/: motor_control.c
    ../Core/Filght/bmp/: bmp280.c bmp280_task.c
    ../Core/Filght/pid/: pid.c
    ../Core/Filght/filght_init/: filght_init.c
    ../Core/Filght/filght_mode/: filght_mode.c fixed_height_mode.c state.c
    ../Core/Filght/bus/: mitt.c mitter.c
    ../Core/Filght/gps/: gps.c
    ../Core/Filght/qmc5883/: qmc5883.c
  group Application/FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/BasicDataStructure
    ../Core/BasicDataStructure/: queue.c linearlist.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Test/Vofa
    ../Core/test/vofa/: vofa.c
software components: CMSIS:CORE 5.5.0
